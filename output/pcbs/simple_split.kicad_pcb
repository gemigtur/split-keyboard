File: output/pcbs/simple_split.kicad_pcb (KiCad board)
At the start: 2 copper layers, 151.1 x 148.4 mm, 59 parts

Commit message: Update: pcbs routed
Parts:
- RST1: moved to B.Cu
